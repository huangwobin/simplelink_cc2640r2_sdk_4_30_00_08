# IAR project rfWsnNodeIntFlashOadClient.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
configuration Release (ARM)
  as the first configuration, except:
  group (top)
    ./: rfWsnNodeIntFlashOadClient.ipcf rfWsnNodeIntFlashOadClient.cfg
