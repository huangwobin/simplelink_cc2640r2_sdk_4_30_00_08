# IAR project cc2640r2lp_stack.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2640R2F TexasInstruments CC2640R2F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CC26XX; CC26XX_R2; DeviceFamily_CC26X0R2; EXT_HAL_ASSERT; FEATURE_OAD; FLASH_ROM_BUILD; GATT_NO_CLIENT; ICALL_EVENTS; ICALL_JT; ICALL_LITE; OSAL_CBTIMER_NUM_TASKS=1; OSAL_SNV=1; POWER_SAVING; SPLIT_APP_STACK_IMAGE; SECURITY; USE_ICALL
  ICCARM.IExtraOptions: --aeabi; -f $SRC_BLE_DIR$\config\build_components.opt; -f $SRC_BLE_DIR$\config\factory_config.opt; -f $EXAMPLE_BLE_ROOT$\tirtos\build_config.opt; -f ..\config\iar_oad_tgt_boundary.bdef; --diag_suppress=Pa050; -Dxdc_target_types__=iar\targets\arm\std.h; --make_all_definitions_weak
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\controller\cc26xx_r2\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\rom; $SRC_BLE_DIR$\common\cc26xx; $SRC_BLE_DIR$\common\cc26xx\npi\stack; $SRC_BLE_DIR$\hal\src\target\_common; $EXAMPLE_BLE_ROOT$\src\stack; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\profiles\roles; $SRC_BLE_DIR$\profiles\oad\cc26xx; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\npi\src; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\services\src\nv; $SRC_BLE_DIR$\services\src\nv\cc26xx; $SRC_BLE_DIR$\services\src\saddr; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\rf_patches; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\inc; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source; $XDCROOT$\packages
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sp_oad_onchip_$PROJ_FNAME$_$CONFIG_NAME$.hex
  prebuild: $TOOLS_BLE_DIR$\lib_search\lib_search.exe $EXAMPLE_BLE_ROOT$\tirtos\build_config.opt $SRC_BLE_DIR$\blelib ..\config\lib_linker.cmd cc2640 $TOOLS_BLE_DIR$\lib_search\lib_search.xml $SRC_BLE_DIR$\symbols
  postbuild: cmd /C "$TOOLS_BLE_DIR$\frontier\frontier.exe  iar $CONFIG_NAME$\List\$TARGET_BNAME$.map ..\config\iar_boundary.bdef ..\config\iar_boundary.xcl & $TOOLS_BLE_DIR$\oad\oad_image_tool.exe --verbose  iar $PROJ_DIR$ 2 -hex1 $EXE_DIR$\$TARGET_BNAME$.hex -bdf ..\config\iar_boundary.xcl -k "$TOOLS_BLE_DIR$\oad\private.pem" -o $EXE_DIR$\$TARGET_BNAME$_oad"
  ILINK.IlinkOutputFile: sp_oad_onchip_$PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: FLASH_ROM_BUILD=2; CC2650=2; OSAL_SNV=1
  ILINK.IlinkIcfFile: $SRC_BLE_DIR$\common\cc26xx\iar\cc26xx_stack_oad.icf
  ILINK.IlinkExtraOptions: -f ..\config\lib_linker.cmd; -f ..\config\iar_oad_tgt_boundary.xcl
  ILINK.IlinkAdditionalLibs: ..\config\ble_r2.symbols; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: startup_entry
configuration FlashROM_unsecure (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CC26XX; CC26XX_R2; DeviceFamily_CC26X0R2; EXT_HAL_ASSERT; FEATURE_OAD; FLASH_ROM_BUILD; GATT_NO_CLIENT; ICALL_EVENTS; ICALL_JT; ICALL_LITE; OSAL_CBTIMER_NUM_TASKS=1; OSAL_SNV=1; POWER_SAVING; SPLIT_APP_STACK_IMAGE; xSECURITY; USE_ICALL
  postbuild: cmd /C "$TOOLS_BLE_DIR$\frontier\frontier.exe iar $CONFIG_NAME$\List\$TARGET_BNAME$.map ..\config\iar_boundary.bdef ..\config\iar_boundary.xcl & $TOOLS_BLE_DIR$\oad\oad_image_tool.exe iar $PROJ_DIR$ 2 -hex1 $EXE_DIR$\$TARGET_BNAME$.hex -bdf ..\config\iar_boundary.xcl -o $EXE_DIR$\$TARGET_BNAME$_oad"
  group HAL/Common
    ../../../../../../../../source/ti/blestack/hal/src/common/: hal_assert.c
  group HAL/Include
    ../../../../../../../../source/ti/blestack/hal/src/inc/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2650/_common
    ../../../../../../../../source/ti/blestack/hal/src/target/_common/: hal_mcu.h
  group HAL/Target/CC2650/Config
    ../../../../../../../../source/ti/blestack/hal/src/target/_common/: hal_board_cfg.h
  group HAL/Target/CC2650/Drivers
    ../../../../../../../../source/ti/blestack/hal/src/target/_common/: hal_flash_wrapper.c hal_rtc_wrapper.h hal_trng_wrapper.c hal_trng_wrapper.h
  group Host
    ../../../../../../../../source/ti/blestack/host/: gatt_uuid.c
    ../../../../../../../../source/ti/blestack/inc/: gatt_uuid.h
  group ICallBLE
    ../../../../../../../../source/ti/blestack/icall/inc/: ble_dispatch.h
    ../../../../../../../../source/ti/blestack/icall/stack/: ble_dispatch_JT.c ble_dispatch_lite.c
    ../../../../../../../../source/ti/blestack/icall/src/: icall_lite_translation.c
  group INCLUDE
    ../../../../../../../../source/ti/blestack/inc/: att.h gap.h gatt.h hci.h l2cap.h linkdb.h sm.h
    ../../../../../../../../source/ti/blestack/controller/cc26xx_r2/inc/: ll.h
  group LIB
    ../config/: lib_linker.cmd
  group NPI
    ../../../../../../../../source/ti/blestack/common/cc26xx/npi/stack/: npi.c
  group OSAL
    ../../../../../../../../source/ti/blestack/osal/src/inc/: comdef.h osal.h osal_bufmgr.h osal_cbtimer.h osal_clock.h osal_memory.h osal_pwrmgr.h osal_snv.h osal_task.h osal_timers.h
    ../../../../../../../../source/ti/blestack/osal/src/common/: osal.c osal_bufmgr.c osal_cbtimer.c osal_clock.c osal_memory_icall.c osal_pwrmgr.c osal_timers.c
    ../../../../../../../../source/ti/blestack/osal/src/mcu/cc26xx/: osal_snv_wrapper.c
  group Profiles
    ../../../../../../../../source/ti/blestack/profiles/roles/: gap.c gapbondmgr.c gapbondmgr.h
    ../../../../../../../../source/ti/blestack/inc/: gapgattserver.h gattservapp.h
    ../../../../../../../../source/ti/blestack/host/: gattservapp_util.c sm_ecc.c
  group ROM
    ../../../../../../../../source/ti/blestack/rom/r2/: common_rom_init.c rom_flash_jt.h rom_init.c
  group Startup
    ../../../../../../../../source/ti/blestack/icall/stack/: ble_user_config.c
    ../../../../../../../../source/ti/blestack/common/cc26xx/: icall_startup.c
    ../../../../../../../../source/ti/blestack/profiles/oad/cc26xx/: oad_image_header_stack.c
    ../../../src/stack/: osal_icall_ble.c
  group Tools
    ../../../../../../../../source/ti/blestack/config/: build_components.opt
    ../../: build_config.opt
    ../../../../../../../../source/ti/blestack/common/cc26xx/iar/: cc26xx_stack_oad.icf
    ../../../../../../../../source/ti/blestack/common/cc26xx/: onboard.c onboard.h
