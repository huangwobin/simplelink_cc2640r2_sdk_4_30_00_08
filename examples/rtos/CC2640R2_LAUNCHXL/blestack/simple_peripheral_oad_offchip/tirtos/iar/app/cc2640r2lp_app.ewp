# IAR project cc2640r2lp_app.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2640R2F TexasInstruments CC2640R2F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_DISPLAY_USE_UART=1; BOARD_DISPLAY_USE_UART_ANSI=1; CC2640R2_LAUNCHXL; CC26XX; CC26XX_R2; DeviceFamily_CC26X0R2; EXT_HAL_ASSERT; HAL_IMAGE_E; HEAPMGR_METRICS; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; LED_DEBUG; MAX_NUM_BLE_CONNS=1; MAX_PDU_SIZE=251; xOAD_BLE_SECURITY; POWER_SAVING; SPLIT_APP_STACK_IMAGE; TBM_ACTIVE_ITEMS_ONLY; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; SECURITY
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_BLE_DIR$\config\build_components.opt; -f $SRC_BLE_DIR$\config\factory_config.opt; -f $EXAMPLE_BLE_ROOT$\tirtos\build_config.opt; -f ..\config\configPkg\compiler.opt.defs; -f ..\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\controller\cc26xx_r2\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$; $SRC_BLE_DIR$\common\cc26xx; $SRC_BLE_DIR$\common\cc26xx\menu; $SRC_BLE_DIR$\common\cc26xx\crc; $SRC_BLE_DIR$\common\cc26xx\bim; $SRC_BLE_DIR$\common\cc26xx\flash_interface; $SRC_BLE_DIR$\common\cc26xx\board_support_pkg\CC2640R2_LAUNCHXL; $EXAMPLE_BLE_ROOT$\src\app; $EXAMPLE_BLE_ROOT$\..\bim_oad_offchip\src\board; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\profiles\dev_info; $SRC_BLE_DIR$\profiles\oad\cc26xx; $SRC_BLE_DIR$\profiles\roles; $SRC_BLE_DIR$\profiles\roles\cc26xx; $SRC_BLE_DIR$\profiles\simple_profile; $SRC_BLE_DIR$\profiles\simple_profile\cc26xx; $SRC_BLE_DIR$\target; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\hal\src\target\cc2650\rom; $SRC_BLE_DIR$\heapmgr; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\services\src\saddr; $SRC_BLE_DIR$\services\src\sdata; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sp_oad_offchip_$PROJ_FNAME$_$CONFIG_NAME$.hex
  prebuild: "$XDCROOT$\xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs "{NO_ROM:0, OAD_IMG_E:1}" -o ..\config\configPkg $EXAMPLE_BLE_ROOT$\tirtos\app_ble.cfg
  postbuild: cmd /C "$TOOLS_BLE_DIR$\oad\oad_image_tool.exe iar $PROJ_DIR$ 1 -hex1 $EXE_DIR$\$TARGET_BNAME$.hex -bdf ..\config\iar_boundary.xcl -hex2 ..\stack\FlashROM\Exe\sp_oad_offchip_cc2640r2lp_stack_FlashROM.hex -k "$TOOLS_BLE_DIR$\oad\private.pem" -o $EXE_DIR$\$TARGET_BNAME$_oad"
  ILINK.IlinkOutputFile: sp_oad_offchip_$PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: CC2650=2; RTOS_ROM=1; xAPP_IMAGE_START=0x0000; OAD_IMG_E=1
  ILINK.IlinkIcfFile: $SRC_BLE_DIR$\common\cc26xx\iar\cc26xx_app_oad.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl
  ILINK.IlinkAdditionalLibs: $ROM_DIR$\ble_rom_releases\cc26xx_r2\Final_Release\common_r2.symbols; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\driverlib\bin\iar\driverlib.lib; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages\ti\dpl\lib\dpl_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\lib\drivers_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\rf\lib\rf_singleMode_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\display\lib\display.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\grlib\lib\iar\m3\grlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROM_unsecure (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_DISPLAY_USE_UART=1; BOARD_DISPLAY_USE_UART_ANSI=1; CC2640R2_LAUNCHXL; CC26XX; CC26XX_R2; DeviceFamily_CC26X0R2; EXT_HAL_ASSERT; HAL_IMAGE_E; HEAPMGR_METRICS; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; LED_DEBUG; MAX_NUM_BLE_CONNS=1; MAX_PDU_SIZE=251; xOAD_BLE_SECURITY; POWER_SAVING; SPLIT_APP_STACK_IMAGE; TBM_ACTIVE_ITEMS_ONLY; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; xSECURITY
  postbuild: cmd /C "$TOOLS_BLE_DIR$\oad\oad_image_tool.exe iar $PROJ_DIR$ 1 -hex1 $EXE_DIR$\$TARGET_BNAME$.hex -bdf ..\config\iar_boundary.xcl -hex2 ..\stack\FlashROM_unsecure\Exe\sp_oad_offchip_cc2640r2lp_stack_FlashROM_unsecure.hex -o $EXE_DIR$\$TARGET_BNAME$_oad"
  group Application
    ../../../../../../../../source/ti/blestack/common/cc26xx/bim/: bim_util.c bim_util.h
    ../../../../../../../../source/ti/blestack/common/cc26xx/: board_key.c board_key.h util.c util.h
    ../../../../../../../../source/ti/blestack/hal/src/common/: hal_assert.c
    ../../../src/app/: simple_peripheral_oad_offchip.c simple_peripheral_oad_offchip.h simple_peripheral_oad_offchip_menu.c simple_peripheral_oad_offchip_menu.h
    ../../../../../../../../source/ti/blestack/common/cc26xx/menu/: two_btn_menu.c two_btn_menu.h
  group Drivers
    ../../../../../../../../source/ti/blestack/hal/src/target/_common/: hal_flash_wrapper.c
  group Drivers/ECC
    ../../../../../../../../source/ti/blestack/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/TRNG
    ../../../../../../../../source/ti/blestack/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group ICall
    ../../../../../../../../source/ti/blestack/heapmgr/: heapmgr.h
    ../../../../../../../../source/ti/blestack/icall/src/: icall.c icall_cc2650.c icall_platform.h icall_user_config.c
    ../../../../../../../../source/ti/blestack/icall/src/inc/: icall.h
    ../../../../../../../../source/ti/blestack/icall/inc/: icall_addrs.h
  group ICallBLE
    ../../../../../../../../source/ti/blestack/icall/app/: ble_user_config.c icall_api_lite.c
    ../../../../../../../../source/ti/blestack/icall/inc/: ble_user_config.h icall_apimsg.h
  group Include
    ../../../../../../../../source/ti/blestack/inc/: gap.h gapgattserver.h gatt.h hci.h
    ../../../../../../../../source/ti/blestack/profiles/roles/: gapbondmgr.h
    ../../../../../../../../source/ti/blestack/osal/src/inc/: osal_snv.h
  group Middleware/ExtFlash
    ../../../../../../../../source/ti/blestack/common/cc26xx/flash_interface/external/: ExtFlash.c ExtFlash.h
  group OAD
    ../../../../../../../../source/ti/blestack/common/cc26xx/crc/: crc32.c crc32.h
    ../../../../../../../../source/ti/blestack/common/cc26xx/flash_interface/: flash_interface.h
    ../../../../../../../../source/ti/blestack/common/cc26xx/flash_interface/external/: flash_interface_ext_rtos.c
    ../../../../../../../../source/ti/blestack/profiles/oad/cc26xx/: oad.c oad.h oad_image_header.h oad_image_header_app.c
  group Profiles
    ../../../../../../../../source/ti/blestack/profiles/dev_info/cc26xx/: devinfoservice.c
    ../../../../../../../../source/ti/blestack/profiles/dev_info/: devinfoservice.h
    ../../../../../../../../source/ti/blestack/inc/: gatt_profile_uuid.h gatt_uuid.h
    ../../../../../../../../source/ti/blestack/host/: gatt_uuid.c gattservapp_util.c
    ../../../../../../../../source/ti/blestack/profiles/roles/cc26xx/: peripheral.c peripheral.h
    ../../../../../../../../source/ti/blestack/profiles/simple_profile/cc26xx/: simple_gatt_profile.c
    ../../../../../../../../source/ti/blestack/profiles/simple_profile/: simple_gatt_profile.h
  group Startup
    ../../../../../../../../source/ti/blestack/target/: board.c
    ../../../../../../../../source/ti/blestack/profiles/oad/cc26xx/: find_stack_entry.c find_stack_entry.h
    ../../../src/app/: main.c
  group Tools
    ../../: app_ble.cfg
    ../../../../../../../../source/ti/blestack/common/cc26xx/iar/: cc26xx_app_oad.icf
