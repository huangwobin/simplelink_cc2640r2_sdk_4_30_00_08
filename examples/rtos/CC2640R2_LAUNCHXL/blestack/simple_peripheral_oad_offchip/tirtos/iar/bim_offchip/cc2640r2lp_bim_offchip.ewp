# IAR project cc2640r2lp_bim_offchip.ewp, settings and files
configuration FlashOnly (ARM, debug)
  General.OGChipSelectEditMenu: CC2640R2F TexasInstruments CC2640R2F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BIM; CC26XX_R2; DeviceFamily_CC26X0R2; SPLIT_APP_STACK_IMAGE; xDEBUG; SECURITY; xFLASH_DEVICE_ERASE
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$; $SRC_BLE_DIR$\inc; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages; $SRC_BLE_DIR$\common\cc26xx\board_support_pkg\CC2640R2_LAUNCHXL\; $XDCROOT$\packages; $EXAMPLE_BLE_ROOT$\cc26xx\board; $EXAMPLE_BLE_ROOT$\cc26xx\; $EXAMPLE_BLE_ROOT$\src; $SRC_BLE_DIR$\common\cc26xx; $SRC_BLE_DIR$\common\cc26xx\crc; $SRC_BLE_DIR$\common\cc26xx\bim; $SRC_BLE_DIR$\common\cc26xx\flash_interface; $SRC_BLE_DIR$\profiles\oad\cc26xx; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\common\cc26xx\sha2; $SRC_BLE_DIR$\common\cc26xx\ecc; $SRC_BLE_DIR$\common\cc26xx\debug; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\driverlib; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sp_oad_offchip_$PROJ_FNAME$_$CONFIG_NAME$.hex
  ILINK.IlinkOutputFile: sp_oad_offchip_$PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: CC2650=2
  ILINK.IlinkIcfFile: $SRC_BLE_DIR$\common\cc26xx\iar\cc26xx_bim_r2.icf
  ILINK.IlinkExtraOptions: --keep __vector_table
  ILINK.IlinkAdditionalLibs: $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\driverlib\bin\iar\driverlib.lib; $SRC_BLE_DIR$\common\cc26xx\sha2\SHA2CC26XX.a; $ROM_DIR$\ble_rom_releases\cc26xx_r2\Final_Release\ble_r2.symbols
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashOnly_unsecure (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BIM; CC26XX_R2; DeviceFamily_CC26X0R2; SPLIT_APP_STACK_IMAGE; xDEBUG; xSECURITY; xFLASH_DEVICE_ERASE
  group Application
    ../../../src/bim_offchip/: bim_main.c ccfg_app_ble.c
    ../../../../../../../../source/ti/blestack/common/cc26xx/bim/: bim_util.c bim_util.h
    ../../../../../../../../source/ti/blestack/common/cc26xx/crc/: crc32.c crc32.h
    ../../../../../../../../source/ti/blestack/common/cc26xx/flash_interface/: flash_interface.h
    ../../../../../../../../source/ti/blestack/common/cc26xx/flash_interface/internal/: flash_interface_internal.c
    ../../../../../../../../source/ti/blestack/common/cc26xx/debug/: led_debug.c led_debug.h
    ../../../../../../../../source/ti/blestack/profiles/oad/cc26xx/: oad_image_header.h
    ../../../../../../../../source/ti/blestack/common/cc26xx/sha2/: SHA2CC26XX.h
    ../../../../../../../../source/ti/blestack/common/cc26xx/ecc/: sign_util.c sign_util.h
    ../../../../../../../../source/ti/devices/cc26x0r2/startup_files/: startup_iar.c
  group Board
    ../../../../../../../../source/ti/blestack/common/cc26xx/board_support_pkg/CC2640R2_LAUNCHXL/: bsp.h
  group Ext Flash
    ../../../../../../../../source/ti/blestack/common/cc26xx/board_support_pkg/CC2640R2_LAUNCHXL/: ext_flash.c ext_flash.h
  group SPI
    ../../../../../../../../source/ti/blestack/common/cc26xx/board_support_pkg/CC2640R2_LAUNCHXL/: bsp_spi.c bsp_spi.h
  group TOOLS
    ../../../../../../../../source/ti/blestack/common/cc26xx/iar/: cc26xx_bim_r2.icf
